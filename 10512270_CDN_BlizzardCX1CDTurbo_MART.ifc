Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-01-24T12:33:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 24 12:33:52 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\78661e6e-2cd0-4738-99e5-c6a37a7b25c8\dc61bc89-c125-4076-8329-bde5718154ab\ifc * Database version: 5507 * Database creation date: Wed Jan 24 12:33:51 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 24 12:33:52 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 24 12:33:52 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 10512270_CDN_BlizzardCX1CDTurbo_MART:41KCE037_CDN_10512270_BlizzardCX1CDTurbo_MART, (2)
In: Default
Type - Material: z_Miele_Design_OBSW
Type - Pset_BuildingElementProxyCommon - Reference: 41KCE037_CDN_10512270_BlizzardCX1CDTurbo_MART
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 41KCE037_CDN_10512270_BlizzardCX1CDTurbo_MART
Type - Pset_ProvisionForVoid - Width: 515 mm; Height: 310 mm; Depth: 310 mm
Material: z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Design_Glass, z_Miele_Design_HVBR, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
